File: Design/PCIe.kicad_sch (KiCad schematic)
At the start: 24 parts

Commit message: project loaded first time
Parts:
- gave numbers to parts that had none: 24
